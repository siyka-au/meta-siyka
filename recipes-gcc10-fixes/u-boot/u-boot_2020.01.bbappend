FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://u-boot-tools-2020.01-gcc-10.patch"
