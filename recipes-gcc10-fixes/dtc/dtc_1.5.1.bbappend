FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://dtc-1.5.1-gcc-10.patch"
