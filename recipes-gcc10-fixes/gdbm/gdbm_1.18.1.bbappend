FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://gdbm-1.18.1-gcc-10.patch"
