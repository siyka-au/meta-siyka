FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://libtirpc-1.2.5-avoid-multiple-definition.patch"
